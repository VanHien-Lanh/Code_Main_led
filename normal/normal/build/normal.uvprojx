# Keil uVision project normal.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN34F788F SONiX
  pack: SONiX.SN34F7_DFP.2.0.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x7E000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SN34F780 +hex
  AfterMake: HexConvert.exe SN34F780 "#H" RW
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c include: ..\..\..\..\..\..\..\Board;..\..\..\..\..\Com;..\..\..\..\..\Peripherals\Include;..\..\..\..\..\Middlewares\Include;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7dffc
  memory RVCT9: RAM 0x20000000 size 0x28000
  group main
    ../src/: main.c sn34f78x_it.c sn34f78x_hal_msp.c
  group bsp
    ../src/: init.c
    ../include/: init.h
  group config
    ../include/: sn34f78x_hal_conf.h
  group driver
    ../../../../../Peripherals/Source/: sn34f78x_hal_rcc.c sn34f78x_hal_flash.c sn34f78x_hal_flash_ex.c sn34f78x_hal_assert.c sn34f78x_hal_gpio.c sn34f78x_hal_scu.c sn34f78x_hal.c sn34f78x_hal_systick.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2
